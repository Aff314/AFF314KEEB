## Firmware/ZMK_config/Kconfig.defconfig
```kconfig
if SHIELD_AFF314KEEB

config ZMK_KEYBOARD_NAME
    default "AFF314KEEB"

CONFIG_EC11=y
CONFIG_EC11_TRIGGER_GLOBAL_THREAD=y

endif
```
